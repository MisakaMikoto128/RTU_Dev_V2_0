# Keil uVision project RTU_Dev_V2_0.uvprojx, settings and files
target RTU_Dev (6220000::V6.22::.\ArmCompilerforEmbedded6.22)
  device: STM32G473VCTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 0021 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32G473xx,ULOG_ENABLED
  c misc: -Wno-invalid-source-encoding
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../CHIP;../LIB;../HDL;..\TEST;..\BFL;..\APP;..\3rdparty;..\3rdparty\AT-Command\include;..\3rdparty\ulog\src;..\TEST;..\B1;..\B2;..\FATFS\Target;..\FATFS\App;..\Middlewares\Third_Party\FatFs\src;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ../APP/: APP_Main.c AsyncTaskList.c APP_RTU_Sampler.c BFL_RTU_Packet.c
  group BFL
    ../BFL/: BFL_LED.c BFL_4G.c log.c BFL_4G_Task.c scheduler.c asyn_sys.c datetime.c
  group CHIP
    ../CHIP/: CHIP_W25Q512.c CHIP_W25Q512_test.c CHIP_W25Q512_QueueFileSystem.c iic.c CHIP_SHT30.c CHIP_EC800M.c
  group HDL
    ../HDL/: HDL_RTC.c HDL_RTC_test.c HDL_Uart.c HDL_Uart_test.c HDL_Flash.c HDL_Flash_test.c HDL_ADC.c HDL_IWDG.c HDL_ADC_test.c HDL_CPU_Time.c HDL_CPU_Time_test.c HDL_SPI.c
  group LIB
    ../LIB/: modbus_host.c sc_list.c sc_byte_buffer.c crc.c circular_array_queu.c cfunction.c mtime.c cqueue.c
  group TEST
    ../TEST/: test.c
  group 3rdparty
    ../3rdparty/AT-Command/src/: at_chat.c at_port.c
    ../3rdparty/ulog/src/: ulog.c
    ../3rdparty/sdcard/: bsp_spi_sdcard.c sdcard_test.c
  group Application/MDK-ARM
    ./: startup_stm32g473xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usb.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_ll_i2c.c stm32g4xx_ll_lpuart.c stm32g4xx_ll_rcc.c stm32g4xx_ll_usart.c stm32g4xx_hal_qspi.c stm32g4xx_ll_rtc.c stm32g4xx_ll_spi.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_tim.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: user_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: app_fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
software components: CMSIS:CORE 5.6.0
